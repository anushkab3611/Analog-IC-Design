v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 -80 -90 -80 70 {}
L 4 -80 -90 70 0 {}
L 4 -80 70 70 0 {}
L 7 70 0 90 0 {}
L 7 -100 30 -80 30 {}
L 7 -100 -50 -80 -50 {}
L 7 -20 40 -20 60 {}
L 7 -30 -80 -30 -60 {}
B 5 87.5 -2.5 92.5 2.5 {name=VOUT dir=inout}
B 5 -102.5 27.5 -97.5 32.5 {name=vip dir=inout}
B 5 -102.5 -52.5 -97.5 -47.5 {name=vim dir=inout}
B 5 -22.5 57.5 -17.5 62.5 {name=AVSS dir=inout}
B 5 -32.5 -82.5 -27.5 -77.5 {name=AVDD dir=inout}
T {@symname} -64 -16 0 0 0.3 0.3 {}
T {@name} -25 -82 0 0 0.2 0.2 {}
T {VOUT} 65 -4 0 1 0.2 0.2 {}
T {vip} -75 34 2 1 0.2 0.2 {}
T {vim} -75 -46 2 1 0.2 0.2 {}
T {AVSS} -16 35 1 1 0.2 0.2 {}
T {AVDD} -34 -55 3 1 0.2 0.2 {}
