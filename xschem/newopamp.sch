v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {vcvs.sym} 0 -10 0 0 {name=E1 value=1000}
C {iopin.sym} -40 -30 2 0 {name=p1 lab=vip
}
C {iopin.sym} -40 10 2 0 {name=p2 lab=vim}
C {iopin.sym} 0 20 0 0 {name=p3 lab=vom}
C {iopin.sym} 0 -40 0 0 {name=p4 lab=vop}
