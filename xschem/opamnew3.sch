v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 -90 -120 -90 40 {}
L 4 -90 -120 60 -30 {}
L 4 -90 40 60 -30 {}
L 7 60 -30 80 -30 {}
L 7 -110 0 -90 0 {}
L 7 -110 -80 -90 -80 {}
L 7 -30 10 -30 30 {}
L 7 -40 -110 -40 -90 {}
B 5 77.5 -32.5 82.5 -27.5 {name=VOUT dir=inout}
B 5 -112.5 -2.5 -107.5 2.5 {name=vip dir=inout}
B 5 -112.5 -82.5 -107.5 -77.5 {name=vim dir=inout}
B 5 -32.5 27.5 -27.5 32.5 {name=AVSS dir=inout}
B 5 -42.5 -112.5 -37.5 -107.5 {name=AVDD dir=inout}
T {@symname} -74 -46 0 0 0.3 0.3 {}
T {@name} -5 -112 0 0 0.2 0.2 {}
T {VOUT} 55 -34 0 1 0.2 0.2 {}
T {vip} -85 4 2 1 0.2 0.2 {}
T {vim} -85 -76 2 1 0.2 0.2 {}
T {AVSS} -26 5 1 1 0.2 0.2 {}
T {AVDD} -44 -85 3 1 0.2 0.2 {}
